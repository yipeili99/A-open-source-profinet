# Keil uVision project Project.uvprojx, settings and files
target GD32470Z_EVAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\..\..\..\..\Utilities;..\inc;..\..\..\Third_party\lwip-2.1.2\src\include;..\..\..\Third_party\lwip-2.1.2\src\include\ipv4;..\..\..\Third_party\lwip-2.1.2\src\include\netif;..\..\..\Third_party\lwip-2.1.2\src\include\lwip;..\..\..\Third_party\lwip-2.1.2\port\GD32F4xx;..\..\..\Third_party\lwip-2.1.2\port\GD32F4xx\FreeRTOS;..\..\..\Third_party\FreeRTOS-10.3.1\portable\RVDS\ARM_CM4F;..\..\..\Third_party\FreeRTOS-10.3.1\include;..\..\..\..\..\..\GD32F4xx_Firmware_Library\CMSIS;..\..\..\Third_party\p-net\include;..\..\..\Third_party\p-net\src;..\..\..\Third_party\p-net\src\common;..\..\..\Third_party\p-net\src\device;..\..\..\Third_party\p-net\src\ports\STM32Cube;..\..\..\Third_party\p-net\osal-src\include;..\..\..\Third_party\p-net\osal-src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../src/: gd32f4xx_enet_eval.c gd32f4xx_it.c hello_gigadevice.c main.c netconf.c udp_echo.c
  group GD32F4xx_Peripherals
    ../../../../../../GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Lwip
    ../src/: tcp_client.c
    ../../../Third_party/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../Third_party/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../Third_party/lwip-2.1.2/src/netif/: ethernet.c
  group Lwip_port
    ../../../Third_party/lwip-2.1.2/port/GD32F4xx/FreeRTOS/: ethernetif.c sys_arch.c
  group FreeRTOS
    ../../../Third_party/FreeRTOS-10.3.1/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Third_party/FreeRTOS-10.3.1/portable/MemMang/: heap_4.c
    ../../../Third_party/FreeRTOS-10.3.1/portable/RVDS/ARM_CM4F/: port.c
  group CMSIS
    ../src/: system_gd32f4xx.c
  group GD32F4xx_EVAL
    ../../../../../Utilities/: gd32f470z_eval.c
  group Startup
    ../../../../../../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Doc
    ../: readme.txt
  group pf_src
    ../../../Third_party/p-net/src/common/: pf_alarm.c pf_bg_worker.c pf_cpm.c pf_cpm_driver_sw.c pf_dcp.c pf_eth.c pf_file.c pf_lldp.c pf_ppm.c pf_ppm_driver_sw.c pf_ptcp.c pf_scheduler.c pf_snmp.c pf_udp.c
    ../../../Third_party/p-net/src/device/: pf_block_reader.c pf_block_writer.c pf_cmdev.c pf_cmdmc.c pf_cmina.c pf_cmio.c pf_cmpbe.c pf_cmrdr.c pf_cmrpc.c pf_cmrpc_epm.c pf_cmrpc_helpers.c pf_cmrs.c pf_cmsm.c pf_cmsu.c pf_cmwrr.c pf_diag.c pf_fspm.c pf_pdport.c pf_plugsm.c pf_port.c pnet_api.c
    ../../../Third_party/p-net/src/ports/STM32Cube/: pnal.c pnal_eth.c pnal_udp.c
  group pf_dev
    ../../../Third_party/p-net/samples/pn_dev/: app_data.c app_gsdml.c app_log.c app_utils.c sampleapp_common.c
  group pf_osal
    ../../../Third_party/p-net/osal-src/: osal.c osal_log.c
software components: CMSIS:CORE 5.5.0
